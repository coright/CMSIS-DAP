# Keil uVision project ATSAM3U2C_interface.uvproj, settings and files
target ATSAM3U2C_nRF51822AA_if (ARM-ADS)
  device: SAM3U2C Atmel
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x00080000-0x0009FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ATSAM3U2C_nRF51822AA_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: TARGET_ATSAM3U2C, __RTX, DBG_NRF51822AA, BOARD_NRF51822AA
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NordicSemi\DBG_nRF51822AA;..\..\interface\hal\TARGET_Atmel\TARGET_ATSAM3U2C;..\..\interface\cmsis;..\..\..\shared\cmsis\TARGET_Atmel\TARGET_ATSAM3U2C;..\..\..\shared\rtos
  memory RVCT4: ROM 0x80000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20080000 size 0x4000
  scatter file: ..\..\..\shared\cmsis\TARGET_Atmel\TARGET_ATSAM3U2C\TOOLCHAIN_ARM_STD\ATSAM3U2C.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Atmel/TARGET_ATSAM3U2C/: system_SAM3U.c
    ../../../shared/cmsis/TARGET_Atmel/TARGET_ATSAM3U2C/TOOLCHAIN_ARM_STD/: startup_SAM3U.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_hs_config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c intelhex.c serial.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_Atmel/TARGET_ATSAM3U2C/: DAP_config.h gpio.c read_uid.c uart.c usb_buf.h usbd_SAM3U2C.c board_ATSAM3U2C.c
  group HAL-Target
    ../../target/hal/DBG_NordicSemi/DBG_nRF51822AA/: target_reset.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c HAL_CM3.c
target ATSAM3U2C_nRF51822AA_if_mbed_bootloader (ARM-ADS)
  device: SAM3U2C Atmel
  cpu: as above
  output: ATSAM3U2C_nRF51822AA_if_mbed_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: TARGET_ATSAM3U2C, __RTX, DBG_NRF51822AA, BOARD_NRF51822AA
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_NordicSemi\DBG_nRF51822AA;..\..\interface\hal\TARGET_Atmel\TARGET_ATSAM3U2C;..\..\interface\cmsis;..\..\..\shared\cmsis\TARGET_Atmel\TARGET_ATSAM3U2C;..\..\..\shared\rtos;..\..\..\..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20080000 size 0x4000
  scatter file: ..\..\..\shared\cmsis\TARGET_Atmel\TARGET_ATSAM3U2C\TOOLCHAIN_ARM_STD\ATSAM3U2C_mbed_bootloader.sct
