# Keil uVision project kl25z128_lpc_interface.uvproj, settings and files
target kl25z128_lpc1114_if (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: kl25z128_lpc1114_if
  c flags: Optim=3
  c define: TARGET_MKL25Z, __RTX, DBG_LPC1114, BOARD_FRDM_KL25Z
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_NXP\DBG_LPC1114;..\..\interface\hal\TARGET_Freescale\TARGET_MKL25Z;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MKL25Z;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MKL25Z\TOOLCHAIN_ARM_STD\MKL25Z4.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MKL25Z/: system_MKL25Z4.c
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MKL25Z/TOOLCHAIN_ARM_STD/: startup_MKL25Z4.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c serial.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface-MKL25Z
    ../../interface/hal/TARGET_Freescale/TARGET_MKL25Z/: DAP_config.h gpio.c read_uid.c uart.c usb_buf.h usbd_MKL25Z4.c
  group HAL-Target-LPC
    ../../target/hal/DBG_NXP/DBG_LPC/: target_reset.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM1.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
target kl25z128_lpc_if (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: kl25z128_lpc_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=4
  c define: TARGET_MKL25Z, __RTX, DBG_LPC, BOARD_LPC1114, WANTED_SIZE_IN_KB=512
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_NXP\DBG_LPC;..\..\interface\hal\TARGET_Freescale\TARGET_MKL25Z;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MKL25Z;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: as above
