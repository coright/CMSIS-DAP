# Keil uVision project k20_bootloader.uvproj, settings and files
target mbed FRDM-K20D5M (ARM-ADS)
  device: MK20DN128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx128_bootloader
  AfterMake: fromelf --bin -o build\k20dx128_bootloader_K20D5M.bin build\k20dx128_bootloader.axf
  c flags: Optim=1
  c define: TARGET_MK20DX,  CPU_MK20DX128VFM5,  __RTX,
  c misc: --debug -e -g
  c include: [['shared/cmsis/TARGET_Freescale/include', 'shared/cmsis/TARGET_Freescale/include/device', 'shared/cmsis/TARGET_Freescale/include/device/MK20D5']];  [['shared/rtos']];  [['bootloader/Common/inc', 'shared/cmsis', 'USBStack/INC']];  [];  [['USBStack/INC']];
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group Source
    ./:     
